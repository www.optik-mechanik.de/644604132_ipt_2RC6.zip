# Autodesk Inventor part: 2RC6-25_uzsakovui
## iProperties
Created: 2007-06
Part Number: 2RC6-25_uzsakovui
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
